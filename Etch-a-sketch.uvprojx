# Keil uVision project Etch-a-sketch.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32L053R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Etch-a-sketch
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: fsm_btn.c fsm_btn.h storage.h storage.c main.c queue.h queue.c knob.h knob.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
